SRCDATE = "20190328"

require hd-bootargs.inc

SRC_URI[md5sum] = "d81dfe2b668510f0e05883642c8a5592"
SRC_URI[sha256sum] = "ab39bce44f68b7d7f91ddc1b43e68b54e4288a7efc36e12de438b02d83da77ab"

COMPATIBLE_MACHINE = "hd60"
