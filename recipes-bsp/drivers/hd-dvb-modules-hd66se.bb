KV = "4.4.35"
SRCDATE = "20220208"

PROVIDES = "virtual/blindscan-dvbs"

require hd-dvb-modules-hisil.inc

SRC_URI[md5sum] = "7b61a1950d9e9846bf84925083ee6327"                                
SRC_URI[sha256sum] = "6cce2b4fa32dfe27aca78cbc4c0c6915723eace4f2adda0f62d7bb66fd552678"

COMPATIBLE_MACHINE = "hd66se"
