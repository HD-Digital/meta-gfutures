KV = "4.10.6"
SRCDATE = "20170329"

require hd-dvb-modules.inc

SRC_URI[md5sum] = "c9c89054616430a862459b6168cecf0e"
SRC_URI[sha256sum] = "d68f61b5e8afe48db390817aa5fb3a100e60d5bc4fabd1e976b0b1a79e1ae764"

COMPATIBLE_MACHINE = "hd51"