SRCDATE = "20220208"

require hd-bootargs.inc

SRC_URI[md5sum] = "7e82eb09e12a90499be8f9dbc24dff6d"                                
SRC_URI[sha256sum] = "6bd91203830adbbf840418a6c23a09c043ce56dc98fcbaeacef97a9cb840033a"

COMPATIBLE_MACHINE = "hd66se"
