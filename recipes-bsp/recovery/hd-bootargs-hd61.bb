SRCDATE = "20200424"

require hd-bootargs.inc

SRC_URI[md5sum] = "87ee164924d865a808bf01f80e4faee1"
SRC_URI[sha256sum] = "1bfd0c0b45d0de739a894917b659b74372e4b35e10189cd642577df277ab083e"

COMPATIBLE_MACHINE = "hd61"
