SRCDATE = "20190417"

require hd-bootargs.inc

SRC_URI[md5sum] = "0d19e2a70f066642fc6590b40e620518"
SRC_URI[sha256sum] = "26633ef854755b78f455b4450dbdfb1404e696d8006857f3e5d7ab8d555b1865"

COMPATIBLE_MACHINE = "hd60"
