SRCDATE = "20190417"

require hd-partitions.inc

SRC_URI[md5sum] = "ef240821ef9c53e50a694aa20357eeb9"
SRC_URI[sha256sum] = "a80d5137916f599a60d167190875446a8c6ea75e80d750c67825719114a86d1a"

COMPATIBLE_MACHINE = "hd60"